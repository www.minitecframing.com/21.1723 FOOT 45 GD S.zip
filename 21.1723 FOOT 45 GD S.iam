# Autodesk Inventor assembly: 21.1723 FOOT 45 GD S
## iProperties
Created: 2007-04
Part Number: 21.1723 FOOT 45 GD S
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
